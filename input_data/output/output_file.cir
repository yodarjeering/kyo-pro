IC3 GND OUT12 OUT11 OUT10 OUT9 OUT8 OUT7 1N1894 1N1651 GND 1N1738 1N1707 1N234 1N1392 1N236 1N243 1N242 1N167 GND VDD
IC20 VCC24 GND 1N167 1N242 1N243 1N236 1N1392 1N234 GND GND GND VCC24 1N1262 1N1264 1N1266 1N1268 1N1731 1N1730
R224 1N237 1N167 3.6K
R119 1N228 VCC24 80A
R216 1N266 1N228 2.2
CN1 VCC24 1N440 1N555 1N285 VCC24 1N440 1N542 1N232
D19 1N440 1N232 1N440
IC19 VCC24 GND 1N519 1N520 1N260 1N521 1N522 1N1382 1N1494 GND GND VCC24 1N1237 1N1245 1N1239 1N1247 1N1241 1N1243 1N232
R190 1N249 1N234 3.6K
R220 1N241 1N236 3.6K
LED6 GND 1N237
LED14 GND 1N238
R189 1N238 1N1392 3.6K
LED15 GND 1N239
R187 1N239 1N242 3.6K
LED16 GND 1N240
R188 1N240 1N243 3.6K
LED4 GND 1N241
LED13 GND 1N249
C251 1N257 GND 0.1U
R198 1N257 1N1209 1K
R199 1N259 1N257 1K
R201 VDD 1N259 47K
TR10 1N941 1N440 1N259
IC2 GND OUT13 OUT4 OUT3 OUT6 OUT2 OUT5 OUT1 GND GND 1N1494 1N1382 1N522 1N521 1N260 1N520 1N519 GND VDD
R222 1N313 1N260 3.6K
L1 1N266 1N440 GND 1N371 0.5MH
IC6 1N537 1N421 GND 1N273 VDD
LED2 1N273 1N275
R193 VDD 1N275 4.7K
LED1 1N276 VDD
R192 1N276 1N619 4.7K
CN8 VDD VDD VDD VDD VDD GND GND GND GND 1N278 1N304 1N461 1N303 1N299 1N298 1N297 1N296 1N300 1N301 1N1166
IC1 1N1865 1N1866 1N788 1N791 AD_SCK GND 1N541 1N427 1N770 GND 1N478 VDD 1N292 1N791 1N1084 1N1104 1N1124 1N1209 1N620 SW2_4 SW2_3 1N461 1N619 1N1612 1N539 SW2_2 SW2_1 1N1175 SW1_8 SW1_4 SW1_2 SW1_1 1N1647 1N1932 1N1651 1N1894 OUT13 OUT12 OUT11 OUT10 OUT9 OUT8 OUT7 OUT6 OUT5 OUT4 OUT3 OUT2 VDD OUT1 GND RCU_DO_ENA RCU_SCK_ENA 1N304 1N303 1N299 1N298 1N297 1N447 1N446 1N448 1N278 1N296 1N300 1N301 1N1166 CH8_DO_ENA CH7_DO_ENA CH6_DO_ENA CH5_DO_ENA CH4_DO_ENA CH3_DO_ENA CH2_DO_ENA CH1_DO_ENA CH8_SCK_ENA CH7_SCK_ENA CH6_SCK_ENA CH5_SCK_ENA CH4_SCK_ENA CH3_SCK_ENA CH2_SCK_ENA GND CH1_SCK_ENA VDD VDD
R155 VDD 1N278 47K
IC5 1N537 GND 1N421 1N619 GND GND 1N433 1N432 1N369 1N284 VDD
R182 1N284 1N434 4.7K
R185 VDD 1N284 47K
R181 1N285 1N941 10K
R179 1N292 VDD 47K
R210 VDD 1N300 47K
R211 VDD 1N301 47K
R208 VDD 1N304 47K
LED10 GND 1N312
R223 1N312 1N521 3.6K
LED9 GND 1N313
LED12 GND 1N314
R227 1N314 1N1382 3.6K
LED11 GND 1N315
R226 1N315 1N522 3.6K
LED8 GND 1N320
R221 1N320 1N520 3.6K
LED5 GND 1N332
R186 1N332 VDD 3.6K
C234 1N339 1N542 0.1U
PC1 1N1901 1N1707 1N339 1N555
R245 1N339 1N542 1.5K
TR1 1N339 1N542 1N555
R191 1N369 1N609 4.7K
R219 1N369 GND 47K
C10 1N371 GND 4.7U
C14 1N371 GND 470U
IC4 1N701 GND 1N680 1N371 1N371 1N705
R176 VDD 1N421 4.7K
TR40 1N539 GND 1N421
C242 1N427 GND 100P
IC43 GND GND 1N427 VDD
R175 VDD 1N427 4.7K
CN2 GND 1N609 1N434 GND 1N432 1N433
CN3 GND 1N609 1N434 GND 1N432 1N433
SW2 GND GND GND GND 1N434 1N609 VDD 1N434 1N608 1N541 1N432 1N433 SW2_4 SW2_3 SW2_2 SW2_1
C2 1N1082 1N440 0.1U
C4 1N1102 1N440 0.1U
C7 1N1126 1N440 0.1U
C253 1N941 1N440 0.1U
C259 VCC24 1N440 1U
CN6 1N1237 1N1239 1N1241 1N1243 1N1245 1N1247 1N440 1N440
CN7 1N1262 1N1264 1N1266 1N1268 1N1731 1N1730 1N1120 1N1100 1N1080 1N440 1N440 1N440
D1 VCC24 1N440 D
D13 1N1243 1N1241 1N440
D14 1N1247 1N1239 1N440
D15 1N1245 1N1237 1N440
D16 1N1730 1N1731 1N440
D17 1N1268 1N1266 1N440
D18 1N1264 1N1262 1N440
R2 1N1082 1N440 1K
R8 1N1102 1N440 1K
R19 1N1126 1N440 1K
R174 1N941 1N440 1K
TR11 1N1126 1N440 1N1125
TR12 1N1102 1N440 1N1103
TR13 1N1082 1N440 1N1083
ZNR1 VCC24 1N440
ZNR2 VCC24 1N440
IC7 GND GND GND GND 1N447 1N446 1N448 VDD
R213 VDD 1N446 4.7K
R214 VDD 1N447 4.7K
R212 VDD 1N448 4.7K
C245 1N461 GND 470P
R217 VDD 1N461 2.2K
C240 1N477 GND 15P
R29 1N770 1N477 3.3K
X1 1N477 GND 1N478 GND
C239 1N478 GND 15P
R156 1N519 1N1728 3.6K
R153 1N1612 1N537 4.7K
R183 VDD 1N537 4.7K
R194 VDD 1N539 4.7K
TR41 1N541 GND 1N539
R178 1N541 GND 47K
D2 1N555 1N542 1N542
R248 1N608 1N609 120
R95 1N620 AD_CLK_MCU 100
R157 VDD 1N620 4.7K
R25 VDD 1N680 30K
R26 1N680 GND 10K
C11 1N701 1N705 0.1U
D4 1N701 VDD VDD
D3 GND 1N705 D
L2 VDD 1N705 22U
R158 VDD 1N788 4.7K
R240 1N788 AD_DIN_MCU 100
C223 1N791 GND 100P
IC46 AD_DOUT 1N791 GND GND 1N1989 1N2016 VDD
R1 1N1080 1N1082 10K
R3 VDD 1N1083 47K
R4 1N1083 1N1087 1K
R5 1N1087 1N1084 1K
C3 1N1087 GND 0.1U
R12 1N1100 1N1102 10K
R9 VDD 1N1103 47K
R10 1N1103 1N1107 1K
R11 1N1107 1N1104 1K
C5 1N1107 GND 0.1U
R13 1N1120 1N1126 10K
C6 1N1121 GND 0.1U
R15 1N1121 1N1124 1K
R17 1N1125 1N1121 1K
R18 VDD 1N1125 47K
R177 GND 1N1175 47K
R24 SW1_8 1N1193 100K
RA1 1N1196 1N1195 1N1194 1N1193 SW2_1 SW2_2 SW2_3 SW2_4 VDD 47k
SW1 1N1196 1N1195 1N1194 GND GND 1N1193
R23 SW1_4 1N1194 100K
R22 SW1_2 1N1195 100K
R21 SW1_1 1N1196 100K
LED7 GND 1N1422
R225 1N1494 1N1422 3.6K
LED3 GND 1N1491
R200 1N1491 1N1738 4.7K
C222 1N1612 GND 470P
R218 VDD 1N1647 47K
R244 VDD 1N1651 47K
LED17 GND 1N1728
R27 VDD 1N1865 47K
R28 VDD 1N1866 47K
R246 VDD 1N1894 47K
R228 VDD 1N1901 1K
PAT19 1N1932
R154 VDD 1N1932 47K
C286 1N1989 GND 470P
R251 1N1989 1N2016 1K
C16 2N8038 2N8037 0.1U
CN5 2N8037 2N8037 2N8038 2N8038 2N8039 2N8039 2N8040 2N8040 TC3- TC3- TC3+ TC3+ TC4- TC4- TC4+ TC4+ TC5- TC5- TC5+ TC5+ TC6- TC6- TC6+ TC6+ RCU+ RCU+ RCU-1 RCU-1 RCU-2 RCU-2 TC7- TC8- TC7+ TC8+
L3 2N8383 2N8037 100
L4 2N8384 2N8038 100
C38 2N8040 2N8039 0.1U
L5 2N8389 2N8039 100
L6 2N8390 2N8040 100
C22 2N8068 2N8365 10U
C23 2N8068 2N8365 0.1U
IC8 2N8148 2N8147 2N8365 2N8365 2N8069 2N8070 2N8365 2N8365 2N8365 2N8365 2N8365 2N8365 2N8068 2N8072 2N8073 2N8074
R41 2N8072 2N8068 10
C12 2N8069 2N8365 100P
C19 2N8069 2N8070 4.7U
R31 2N8069 2N8084 1K
R33 2N8097 2N8069 10M
C241 2N8070 2N8365 100P
R32 2N8070 2N8083 1K
R35 2N8097 2N8070 10M
C21 2N8072 2N8365 0.1U
C27 2N8072 2N8365 0.1U
C30 2N8072 2N8365 0.1U
C35 2N8072 2N8365 10U
IC26 VDD GND 2N8086 2N8085 2N8124 2N8110 VDD GND 2N8365 2N8072 2N8073 2N8074 2N8148 2N8147 2N8365 2N8072
IC35 2N8113 2N8365 2N8113 2N8072
PAT3 2N8072
R34 2N8072 2N8097 2.2K
R36 2N8072 2N8076 10M
R160 2N8072 2N8147 10K
R161 2N8072 2N8148 10K
R162 2N8072 2N8074 10K
R163 2N8072 2N8073 10K
C29 2N8075 2N8365 4.7U
L22 2N8075 2N8383 100
R42 2N8083 2N8075 1K
C17 2N8076 2N8365 4.7U
L23 2N8076 2N8384 100
R30 2N8084 2N8076 1K
T1 2N8079 VDD 2N8107 2N8132 2N8365 2N8082
TR2 DC_DC1 GND DC_DC2 2N8107 GND 2N8079
D5 2N8082 2N8132 2N8113
C18 2N8084 2N8083 4.7U
C34 2N8085 GND 100P
IC22 CH1_DO_ENA 2N8110 AD_DOUT CH1_SCK_ENA AD_SCK 2N8085 GND AD_DOUT 2N8196 CH2_DO_ENA 2N8171 AD_SCK CH2_SCK_ENA VDD
R38 VDD 2N8085 47K
R37 AD_CLK 2N8086 100
C20 2N8097 2N8365 10U
REG1 2N8097 2N8365 2N8097 2N8097
C32 2N8110 GND 100P
R40 VDD 2N8110 47K
C36 2N8113 2N8365 2.2U
R39 AD_DIN 2N8124 100
C44 2N8154 2N8366 10U
C45 2N8154 2N8366 0.1U
IC9 2N8234 2N8233 2N8366 2N8366 2N8155 2N8156 2N8366 2N8366 2N8366 2N8366 2N8366 2N8366 2N8154 2N8158 2N8159 2N8160
R54 2N8158 2N8154 10
C41 2N8155 2N8156 4.7U
C243 2N8155 2N8366 100P
R44 2N8155 2N8170 1K
R46 2N8183 2N8155 10M
C266 2N8156 2N8366 100P
R45 2N8156 2N8169 1K
R48 2N8183 2N8156 10M
C43 2N8158 2N8366 0.1U
C49 2N8158 2N8366 0.1U
C52 2N8158 2N8366 0.1U
C57 2N8158 2N8366 10U
IC27 VDD GND 2N8172 2N8171 2N8210 2N8196 VDD GND 2N8366 2N8158 2N8159 2N8160 2N8234 2N8233 2N8366 2N8158
IC36 2N8199 2N8366 2N8199 2N8158
PAT5 2N8158
R47 2N8158 2N8183 2.2K
R49 2N8158 2N8162 10M
R164 2N8158 2N8233 10K
R165 2N8158 2N8234 10K
R166 2N8158 2N8160 10K
R167 2N8158 2N8159 10K
C51 2N8161 2N8366 4.7U
L24 2N8161 2N8389 100
R55 2N8169 2N8161 1K
C39 2N8162 2N8366 4.7U
L25 2N8162 2N8390 100
R43 2N8170 2N8162 1K
T2 2N8165 VDD 2N8193 2N8218 2N8366 2N8168
TR3 DC_DC1 GND DC_DC2 2N8193 GND 2N8165
D6 2N8168 2N8218 2N8199
C40 2N8170 2N8169 4.7U
C56 2N8171 GND 100P
R51 VDD 2N8171 47K
R50 AD_CLK 2N8172 100
C42 2N8183 2N8366 10U
REG2 2N8183 2N8366 2N8183 2N8183
C54 2N8196 GND 100P
R53 VDD 2N8196 47K
C58 2N8199 2N8366 2.2U
R52 AD_DIN 2N8210 100
PAT4 2N8365
PAT6 2N8366
C67 3N646 3N938 10U
C68 3N646 3N938 0.1U
IC10 3N726 3N725 3N938 3N938 3N647 3N648 3N938 3N938 3N938 3N938 3N938 3N938 3N646 3N650 3N651 3N652
R67 3N650 3N646 10
C64 3N647 3N648 4.7U
C267 3N647 3N938 100P
R57 3N647 3N662 1K
R59 3N675 3N647 10M
C268 3N648 3N938 100P
R58 3N648 3N661 1K
R61 3N675 3N648 10M
C66 3N650 3N938 0.1U
C72 3N650 3N938 0.1U
C75 3N650 3N938 0.1U
C80 3N650 3N938 10U
IC28 VDD GND 3N663 3N932 3N702 3N688 VDD GND 3N938 3N650 3N651 3N652 3N726 3N725 3N938 3N650
IC37 3N691 3N938 3N691 3N650
PAT7 3N650
R60 3N650 3N675 2.2K
R62 3N650 3N654 10M
R168 3N650 3N725 10K
R169 3N650 3N726 10K
R170 3N650 3N652 10K
R171 3N650 3N651 10K
C74 3N653 3N938 4.7U
L26 3N653 3N957 100
R68 3N661 3N653 1K
C62 3N654 3N938 4.7U
L27 3N654 3N956 100
R56 3N662 3N654 1K
T3 3N657 VDD 3N685 3N710 3N938 3N660
TR4 DC_DC1 GND DC_DC2 3N685 GND 3N657
D7 3N660 3N710 3N691
C63 3N662 3N661 4.7U
R63 AD_CLK 3N663 100
C65 3N675 3N938 10U
REG3 3N675 3N938 3N675 3N675
C77 3N688 GND 100P
IC23 CH3_DO_ENA 3N688 AD_DOUT CH3_SCK_ENA AD_SCK 3N932 GND AD_DOUT 3N774 CH4_DO_ENA 3N935 AD_SCK CH4_SCK_ENA VDD
R66 VDD 3N688 47K
C81 3N691 3N938 2.2U
R65 AD_DIN 3N702 100
C89 3N732 3N939 10U
C90 3N732 3N939 0.1U
IC11 3N812 3N811 3N939 3N939 3N733 3N734 3N939 3N939 3N939 3N939 3N939 3N939 3N732 3N736 3N737 3N738
R80 3N736 3N732 10
C86 3N733 3N734 4.7U
C269 3N733 3N939 100P
R70 3N733 3N748 1K
R72 3N761 3N733 10M
C270 3N734 3N939 100P
R71 3N734 3N747 1K
R74 3N761 3N734 10M
C88 3N736 3N939 0.1U
C94 3N736 3N939 0.1U
C97 3N736 3N939 0.1U
C102 3N736 3N939 10U
IC29 VDD GND 3N749 3N935 3N788 3N774 VDD GND 3N939 3N736 3N737 3N738 3N812 3N811 3N939 3N736
IC38 3N777 3N939 3N777 3N736
PAT9 3N736
R73 3N736 3N761 2.2K
R75 3N736 3N740 10M
R172 3N736 3N811 10K
R173 3N736 3N812 10K
R184 3N736 3N738 10K
R195 3N736 3N737 10K
C96 3N739 3N939 4.7U
L28 3N739 3N962 100
R81 3N747 3N739 1K
C84 3N740 3N939 4.7U
L29 3N740 3N963 100
R69 3N748 3N740 1K
T4 3N743 VDD 3N771 3N796 3N939 3N746
TR5 DC_DC1 GND DC_DC2 3N771 GND 3N743
D8 3N746 3N796 3N777
C85 3N748 3N747 4.7U
R76 AD_CLK 3N749 100
C87 3N761 3N939 10U
REG4 3N761 3N939 3N761 3N761
C99 3N774 GND 100P
R79 VDD 3N774 47K
C103 3N777 3N939 2.2U
R78 AD_DIN 3N788 100
C79 3N932 GND 100P
R64 VDD 3N932 47K
C101 3N935 GND 100P
R77 VDD 3N935 47K
PAT8 3N938
PAT10 3N939
L8 3N956 TC3+ 100
L7 3N957 TC3- 100
L9 3N962 TC4- 100
L10 3N963 TC4+ 100
C115 4N651 GND 100P
IC32 VDD GND 4N830 4N1585 4N835 4N651 VDD GND 4N1596 4N750 4N1047 4N1048 4N1049 4N1050 4N1596 4N750
IC45 RCU_DO_ENA 4N651 AD_DOUT RCU_SCK_ENA AD_SCK 4N1585 GND 4N1637 AD_CLK_MCU GND 4N1638 AD_DIN_MCU GND VDD
R117 VDD 4N651 47K
D10 4N758 4N749 4N757
T6 4N1059 VDD 4N1060 4N749 4N1596 4N758
C109 4N750 4N1596 0.1U
C111 4N750 4N1596 0.1U
C145 4N750 4N1596 0.1U
C151 4N750 4N1596 0.1U
C153 4N750 4N1596 0.1U
C159 4N750 4N1596 10U
IC13 4N1384 4N1383 4N1596 4N1596 4N1305 4N1306 4N1596 4N1596 4N1596 4N1596 4N1596 4N1596 4N1304 4N750 4N1309 4N1310
IC14 4N1049 4N1050 4N1596 4N1052 4N797 4N787 4N1596 4N1596 4N783 4N1596 4N794 4N1596 4N782 4N750 4N1047 4N1048
IC31 VDD GND 4N1321 4N1582 4N1360 4N1346 VDD GND 4N1596 4N750 4N1309 4N1310 4N1384 4N1383 4N1596 4N750
IC40 4N757 4N1596 4N757 4N750
PAT13 4N750
R82 4N750 4N782 10
R101 4N750 4N1333 2.2K
R103 4N750 4N1312 10M
R108 4N750 4N1304 10
R204 4N750 4N1383 10K
R205 4N750 4N1384 10K
R206 4N750 4N1310 10K
R209 4N750 4N1309 10K
R215 4N750 4N1050 10K
R229 4N750 4N1049 10K
R230 4N750 4N1048 10K
R231 4N750 4N1047 10K
C105 4N757 4N1596 2.2U
C107 4N782 4N1596 10U
C108 4N782 4N1596 0.1U
C169 4N783 4N1596 4.7U
R118 4N783 4N847 1K
C164 4N797 4N787 4.7U
C276 4N787 4N1596 100P
R113 4N787 4N791 1K
C163 4N799 4N791 4.7U
R112 4N791 4N795 1K
C278 4N794 4N1596 100P
R121 4N794 4N795 1K
C161 4N795 4N1596 4.7U
L35 4N795 4N1661 100
C275 4N797 4N1596 100P
R111 4N797 4N799 1K
C162 4N798 4N1596 4.7U
L36 4N798 4N1660 100
R110 4N799 4N798 1K
R122 4N1052 4N798 1K
R114 AD_CLK 4N830 100
R116 AD_DIN 4N835 100
C168 4N847 4N1596 4.7U
R241 4N847 4N861 1K
C170 4N861 4N1596 4.7U
L34 4N861 4N1662 100
R123 4N861 4N1596 620
C277 4N1052 4N1596 100P
TR6 DC_DC1 GND DC_DC2 4N1060 GND 4N1059
C124 4N1218 4N1594 10U
C125 4N1218 4N1594 0.1U
IC12 4N1298 4N1297 4N1594 4N1594 4N1219 4N1220 4N1594 4N1594 4N1594 4N1594 4N1594 4N1594 4N1218 4N1222 4N1223 4N1224
R94 4N1222 4N1218 10
C121 4N1219 4N1220 4.7U
C271 4N1219 4N1594 100P
R84 4N1219 4N1234 1K
R86 4N1247 4N1219 10M
C272 4N1220 4N1594 100P
R85 4N1220 4N1233 1K
R88 4N1247 4N1220 10M
C123 4N1222 4N1594 0.1U
C129 4N1222 4N1594 0.1U
C132 4N1222 4N1594 0.1U
C137 4N1222 4N1594 10U
IC30 VDD GND 4N1235 4N1580 4N1274 4N1260 VDD GND 4N1594 4N1222 4N1223 4N1224 4N1298 4N1297 4N1594 4N1222
IC39 4N1263 4N1594 4N1263 4N1222
PAT11 4N1222
R87 4N1222 4N1247 2.2K
R89 4N1222 4N1226 10M
R196 4N1222 4N1297 10K
R197 4N1222 4N1298 10K
R202 4N1222 4N1224 10K
R203 4N1222 4N1223 10K
C131 4N1225 4N1594 4.7U
L30 4N1225 4N1645 100
R96 4N1233 4N1225 1K
C119 4N1226 4N1594 4.7U
L31 4N1226 4N1646 100
R83 4N1234 4N1226 1K
T5 4N1229 VDD 4N1257 4N1282 4N1594 4N1232
TR7 DC_DC1 GND DC_DC2 4N1257 GND 4N1229
D9 4N1232 4N1282 4N1263
C120 4N1234 4N1233 4.7U
R90 AD_CLK 4N1235 100
C122 4N1247 4N1594 10U
REG5 4N1247 4N1594 4N1247 4N1247
C134 4N1260 GND 100P
IC24 CH5_DO_ENA 4N1260 AD_DOUT CH5_SCK_ENA AD_SCK 4N1580 GND AD_DOUT 4N1346 CH6_DO_ENA 4N1582 AD_SCK CH6_SCK_ENA VDD
R93 VDD 4N1260 47K
C138 4N1263 4N1594 2.2U
R92 AD_DIN 4N1274 100
C146 4N1304 4N1596 10U
C147 4N1304 4N1596 0.1U
C143 4N1305 4N1306 4.7U
C273 4N1305 4N1596 100P
R98 4N1305 4N1320 1K
R100 4N1333 4N1305 10M
C274 4N1306 4N1596 100P
R99 4N1306 4N1319 1K
R102 4N1333 4N1306 10M
C152 4N1311 4N1596 4.7U
L32 4N1311 4N1652 100
R109 4N1319 4N1311 1K
C141 4N1312 4N1596 4.7U
L33 4N1312 4N1653 100
R97 4N1320 4N1312 1K
C142 4N1320 4N1319 4.7U
R104 AD_CLK 4N1321 100
C144 4N1333 4N1596 10U
REG6 4N1333 4N1596 4N1333 4N1333
C155 4N1346 GND 100P
R107 VDD 4N1346 47K
R106 AD_DIN 4N1360 100
C136 4N1580 GND 100P
R91 VDD 4N1580 47K
C157 4N1582 GND 100P
R105 VDD 4N1582 47K
C167 4N1585 GND 100P
R115 VDD 4N1585 47K
PAT12 4N1594
PAT14 4N1596
R249 4N1637 AD_CLK 100
R250 4N1638 AD_DIN 100
L14 4N1645 TC5- 100
L15 4N1646 TC5+ 100
L16 4N1652 TC6- 100
L17 4N1653 TC6+ 100
L11 4N1660 RCU+ 100
L12 4N1661 RCU-1 100
L13 4N1662 RCU-2 100
C178 5N436 5N772 10U
C179 5N436 5N772 0.1U
IC15 5N516 5N515 5N772 5N772 5N437 5N438 5N772 5N772 5N772 5N772 5N772 5N772 5N436 5N440 5N441 5N442
R135 5N440 5N436 10
C175 5N437 5N438 4.7U
C279 5N437 5N772 100P
R125 5N437 5N452 1K
R127 5N465 5N437 10M
C280 5N438 5N772 100P
R126 5N438 5N451 1K
R129 5N465 5N438 10M
C177 5N440 5N772 0.1U
C183 5N440 5N772 0.1U
C186 5N440 5N772 0.1U
C191 5N440 5N772 10U
IC33 VDD GND 5N765 5N766 5N492 5N478 VDD GND 5N772 5N440 5N441 5N442 5N516 5N515 5N772 5N440
IC41 5N481 5N772 5N481 5N440
PAT15 5N440
R128 5N440 5N465 2.2K
R130 5N440 5N444 10M
R232 5N440 5N515 10K
R233 5N440 5N516 10K
R234 5N440 5N442 10K
R235 5N440 5N441 10K
C185 5N443 5N772 4.7U
L37 5N443 5N790 100
R136 5N451 5N443 1K
C173 5N444 5N772 4.7U
L38 5N444 5N791 100
R124 5N452 5N444 1K
T7 5N447 VDD 5N475 5N500 5N772 5N450
TR8 DC_DC1 GND DC_DC2 5N475 GND 5N447
D11 5N450 5N500 5N481
C174 5N452 5N451 4.7U
C176 5N465 5N772 10U
REG7 5N465 5N772 5N465 5N465
C188 5N478 GND 100P
IC44 CH7_DO_ENA 5N478 AD_DOUT CH7_SCK_ENA AD_SCK 5N766 GND AD_DOUT 5N564 CH8_DO_ENA 5N768 AD_SCK CH8_SCK_ENA VDD
R134 VDD 5N478 47K
C192 5N481 5N772 2.2U
R133 AD_DIN 5N492 100
C200 5N522 5N773 10U
C201 5N522 5N773 0.1U
IC16 5N602 5N601 5N773 5N773 5N523 5N524 5N773 5N773 5N773 5N773 5N773 5N773 5N522 5N526 5N527 5N528
R148 5N526 5N522 10
C197 5N523 5N524 4.7U
C281 5N523 5N773 100P
R138 5N523 5N538 1K
R140 5N551 5N523 10M
C282 5N524 5N773 100P
R139 5N524 5N537 1K
R142 5N551 5N524 10M
C199 5N526 5N773 0.1U
C205 5N526 5N773 0.1U
C208 5N526 5N773 0.1U
C213 5N526 5N773 10U
IC34 VDD GND 5N539 5N768 5N578 5N564 VDD GND 5N773 5N526 5N527 5N528 5N602 5N601 5N773 5N526
IC42 5N567 5N773 5N567 5N526
PAT17 5N526
R141 5N526 5N551 2.2K
R143 5N526 5N530 10M
R236 5N526 5N601 10K
R237 5N526 5N602 10K
R238 5N526 5N528 10K
R239 5N526 5N527 10K
C207 5N529 5N773 4.7U
L39 5N529 5N796 100
R149 5N537 5N529 1K
C195 5N530 5N773 4.7U
L40 5N530 5N797 100
R137 5N538 5N530 1K
T8 5N533 VDD 5N561 5N586 5N773 5N536
TR9 DC_DC1 GND DC_DC2 5N561 GND 5N533
D12 5N536 5N586 5N567
C196 5N538 5N537 4.7U
R144 AD_CLK 5N539 100
C198 5N551 5N773 10U
REG8 5N551 5N773 5N551 5N551
C210 5N564 GND 100P
R147 VDD 5N564 47K
C214 5N567 5N773 2.2U
R146 AD_DIN 5N578 100
C219 5N611 5N609 1000P
R151 5N610 5N609 3.6K
R152 5N617 5N609 10K
IC17 5N617 5N611 5N611 GND 5N610 5N612 5N612 VDD
IC21 5N610 5N616 5N616 GND 5N615 VDD VDD VDD
IC18 5N614 5N614 GND GND 5N618 5N613 VDD
IC25 5N616 5N614 DC_DC2 GND 5N613 5N615 DC_DC1 VDD
R150 5N615 5N618 7.5K
C220 5N618 GND 100P
R131 AD_CLK 5N765 100
C190 5N766 GND 100P
R132 VDD 5N766 47K
C212 5N768 GND 100P
R145 VDD 5N768 47K
PAT16 5N772
PAT18 5N773
L18 5N790 TC7- 100
L19 5N791 TC7+ 100
L20 5N796 TC8- 100
L21 5N797 TC8+ 100
C33 AD_CLK GND 100P
C55 AD_CLK GND 100P
C78 AD_CLK GND 100P
C100 AD_CLK GND 100P
C113 AD_CLK GND 100P
C135 AD_CLK GND 100P
C156 AD_CLK GND 100P
C189 AD_CLK GND 100P
C211 AD_CLK GND 100P
C31 AD_DIN GND 100P
C53 AD_DIN GND 100P
C76 AD_DIN GND 100P
C98 AD_DIN GND 100P
C114 AD_DIN GND 100P
C133 AD_DIN GND 100P
C154 AD_DIN GND 100P
C187 AD_DIN GND 100P
C209 AD_DIN GND 100P
R180 VDD AD_DOUT 4.7K
R159 VDD AD_SCK 4.7K
C226 CH1_DO_ENA GND 100P
RA4 CH5_DO_ENA CH6_DO_ENA CH7_DO_ENA CH8_DO_ENA CH1_DO_ENA CH2_DO_ENA CH3_DO_ENA CH4_DO_ENA VDD 47k
C227 CH1_SCK_ENA GND 100P
RA5 CH8_SCK_ENA CH7_SCK_ENA CH6_SCK_ENA CH5_SCK_ENA CH4_SCK_ENA CH3_SCK_ENA CH2_SCK_ENA CH1_SCK_ENA VDD 47k
C228 CH2_DO_ENA GND 100P
C229 CH2_SCK_ENA GND 100P
C230 CH3_DO_ENA GND 100P
C231 CH3_SCK_ENA GND 100P
C236 CH4_DO_ENA GND 100P
C244 CH4_SCK_ENA GND 100P
C254 CH5_DO_ENA GND 100P
C255 CH5_SCK_ENA GND 100P
C256 CH6_DO_ENA GND 100P
C257 CH6_SCK_ENA GND 100P
C262 CH7_DO_ENA GND 100P
C263 CH7_SCK_ENA GND 100P
C264 CH8_DO_ENA GND 100P
C265 CH8_SCK_ENA GND 100P
C1 VDD GND 22U
C8 VCC24 GND 0.1U
C9 VCC24 GND 0.1U
C13 VDD GND 22U
C26 VDD GND 0.1U
C28 VDD GND 2.2U
C48 VDD GND 0.1U
C50 VDD GND 2.2U
C59 VDD GND 0.1U
C71 VDD GND 0.1U
C73 VDD GND 2.2U
C93 VDD GND 0.1U
C95 VDD GND 2.2U
C128 VDD GND 0.1U
C130 VDD GND 2.2U
C150 VDD GND 0.1U
C158 VDD GND 0.1U
C160 VDD GND 2.2U
C166 VDD GND 0.1U
C182 VDD GND 0.1U
C184 VDD GND 2.2U
C204 VDD GND 0.1U
C206 VDD GND 2.2U
C215 GND VDD 0.1U
C216 VDD GND 0.1U
C217 GND VDD 0.1U
C218 VDD GND 0.1U
C221 VDD GND 0.1U
C224 VDD GND 0.1U
C225 VDD GND 0.1U
C232 GND VDD 0.1U
C233 VDD GND 0.1U
C235 VDD GND 0.1U
C237 VDD GND 0.1U
C238 VDD GND 0.1U
C248 GND VDD 0.1U
C249 VDD GND 0.1U
C250 VDD GND 0.1U
C252 VDD GND 0.1U
C260 RCU_DO_ENA GND 100P
C261 RCU_SCK_ENA GND 100P
C283 VCC24 GND 1U
C284 VCC24 GND 1U
C285 GND VDD 0.1U
PAT1 GND
PAT20 GND
RA2 OUT12 OUT11 OUT10 OUT9 OUT8 OUT7 GND 47k
RA3 OUT13 OUT4 OUT3 OUT6 OUT2 OUT5 OUT1 GND 47k
C116 RCU+ RCU-2 0.1U
C165 RCU+ RCU-1 0.1U
C104 RCU-1 RCU-2 0.1U
R16 VDD RCU_DO_ENA 47K
R14 VDD RCU_SCK_ENA 47K
C61 TC3+ TC3- 0.1U
C83 TC4+ TC4- 0.1U
C118 TC5+ TC5- 0.1U
C140 TC6+ TC6- 0.1U
C172 TC7+ TC7- 0.1U
C194 TC8+ TC8- 0.1U
PAT2 VDD
* label nodes start
V_AD_CLK 0 AD_CLK DC 5
V_AD_CLK_MCU 0 AD_CLK_MCU DC 5
V_AD_DIN 0 AD_DIN DC 5
V_AD_DIN_MCU 0 AD_DIN_MCU DC 5
V_AD_DOUT 0 AD_DOUT DC 5
V_AD_SCK 0 AD_SCK DC 5
V_CH1_DO_ENA 0 CH1_DO_ENA DC 5
V_CH1_SCK_ENA 0 CH1_SCK_ENA DC 5
V_CH2_DO_ENA 0 CH2_DO_ENA DC 5
V_CH2_SCK_ENA 0 CH2_SCK_ENA DC 5
V_CH3_DO_ENA 0 CH3_DO_ENA DC 5
V_CH3_SCK_ENA 0 CH3_SCK_ENA DC 5
V_CH4_DO_ENA 0 CH4_DO_ENA DC 5
V_CH4_SCK_ENA 0 CH4_SCK_ENA DC 5
V_CH5_DO_ENA 0 CH5_DO_ENA DC 5
V_CH5_SCK_ENA 0 CH5_SCK_ENA DC 5
V_CH6_DO_ENA 0 CH6_DO_ENA DC 5
V_CH6_SCK_ENA 0 CH6_SCK_ENA DC 5
V_CH7_DO_ENA 0 CH7_DO_ENA DC 5
V_CH7_SCK_ENA 0 CH7_SCK_ENA DC 5
V_CH8_DO_ENA 0 CH8_DO_ENA DC 5
V_CH8_SCK_ENA 0 CH8_SCK_ENA DC 5
V_DC_DC1 0 DC_DC1 DC 5
V_DC_DC2 0 DC_DC2 DC 5
V_GND 0 GND DC 5
V_OUT1 0 OUT1 DC 5
V_OUT10 0 OUT10 DC 5
V_OUT11 0 OUT11 DC 5
V_OUT12 0 OUT12 DC 5
V_OUT13 0 OUT13 DC 5
V_OUT2 0 OUT2 DC 5
V_OUT3 0 OUT3 DC 5
V_OUT4 0 OUT4 DC 5
V_OUT5 0 OUT5 DC 5
V_OUT6 0 OUT6 DC 5
V_OUT7 0 OUT7 DC 5
V_OUT8 0 OUT8 DC 5
V_OUT9 0 OUT9 DC 5
V_RCU+ 0 RCU+ DC 5
V_RCU-1 0 RCU-1 DC 5
V_RCU-2 0 RCU-2 DC 5
V_RCU_DO_ENA 0 RCU_DO_ENA DC 5
V_RCU_SCK_ENA 0 RCU_SCK_ENA DC 5
V_SW1_1 0 SW1_1 DC 5
V_SW1_2 0 SW1_2 DC 5
V_SW1_4 0 SW1_4 DC 5
V_SW1_8 0 SW1_8 DC 5
V_SW2_1 0 SW2_1 DC 5
V_SW2_2 0 SW2_2 DC 5
V_SW2_3 0 SW2_3 DC 5
V_SW2_4 0 SW2_4 DC 5
V_TC3+ 0 TC3+ DC 5
V_TC3- 0 TC3- DC 5
V_TC4+ 0 TC4+ DC 5
V_TC4- 0 TC4- DC 5
V_TC5+ 0 TC5+ DC 5
V_TC5- 0 TC5- DC 5
V_TC6+ 0 TC6+ DC 5
V_TC6- 0 TC6- DC 5
V_TC7+ 0 TC7+ DC 5
V_TC7- 0 TC7- DC 5
V_TC8+ 0 TC8+ DC 5
V_TC8- 0 TC8- DC 5
V_VCC24 0 VCC24 DC 5
V_VDD 0 VDD DC 5
* label nodes end
* .directive_placeholder
.backanno
.end
